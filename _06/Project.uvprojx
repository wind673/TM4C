# Keil uVision project Project.uvprojx, settings and files
target Project (ARM-ADS)
  device: TM4C123GH6PZ Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\_01_APP;.\_02_System;.\_03_Drive\_01_Interior;.\_03_Drive\_02_External;.\_00_Important\Inc;.\_00_Important\Lib;.\_05_User
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ./_05_User/: main.c
  group System
    ./_02_System/: My_Delay.c
  group Drive
    ./_03_Drive/_01_Interior/: My_GPIO.c My_Timer.c
  group Start File
    ./_00_Important/Start File/: startup_TM4C123.s system_TM4C123.c TM4C123GH6PZ.h cmsis_armcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h system_TM4C123.h TM4C123.h
  group Library
    ./_00_Important/Lib/: gpio.c interrupt.c cpu.c
  group DOC
    ./_04_Doc/: Introduce.txt Temporary.txt
